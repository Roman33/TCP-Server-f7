# Keil uVision project LAN.uvprojx, settings and files
target LAN (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: LAN
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ../Inc;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;../Drivers/CMSIS/Include;..\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_i2c.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_pwr.c stm32f7xx_hal_flash.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_eth.c stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_tim.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_i2c_ex.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4.c dhcp.c igmp.c icmp.c autoip.c etharp.c ip4_frag.c ip4_addr.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: utils.c multilink.c pppos.c chap-new.c pppoe.c fsm.c ipcp.c lcp.c upap.c ppp.c pppol2tp.c pppapi.c magic.c chap_ms.c ipv6cp.c mppe.c chap-md5.c demand.c pppcrypt.c auth.c eui64.c ccp.c eap.c vj.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/core/: tcp_in.c tcp.c stats.c tcp_out.c raw.c ip.c mem.c def.c dns.c pbuf.c netif.c udp.c inet_chksum.c sys.c init.c memp.c timeouts.c
    ../Middlewares/Third_Party/LwIP/src/api/: err.c netifapi.c sockets.c netdb.c netbuf.c tcpip.c api_msg.c api_lib.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ethip6.c icmp6.c ip6.c inet6.c ip6_addr.c mld6.c ip6_frag.c nd6.c dhcp6.c
    ../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c ethernet.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/User
    ../Src/: stm32f7xx_it.c main.c stm32f7xx_hal_msp.c lwip.c ethernetif.c
  group New Group
    ../lib/: udp_echoclient.c
software components: CMSIS:CORE 4.3.0
